# Repository madcatse/isa-ram-expansion

## KiCad design XT Prototype Board.kicad_pcb

Schematic: XT Prototype Board.kicad_sch, 8-bit ISA RAM Expansion Board

Parts:
C1, C2, C3, C4, C5: 0.1UF; C_Disc_D3.0mm_W2.0mm_P2.50mm
C6, C7: 47UF; CP_Radial_D4.0mm_P2.00mm
D1: LED; LED_D3.0mm
J1: Bus_ISA_8bit; Conn_Edge_PCB_ISA8
J2: Breakout; PinHeader_2x31_P2.54mm_Vertical
JP1: Enable RAM; PinHeader_1x02_P2.54mm_Vertical
JP2: 128k / 64k UMB; PinHeader_1x03_P2.54mm_Vertical
JP3: Bypass Logic; PinHeader_1x02_P2.54mm_Vertical
R1: 460; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R2: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RN1: R_Network08; R_Array_SIP9
SW1: SW_DIP_x08; SW_DIP_SPSTx08_Slide_9.78x22.5mm_W7.62mm_P2.54mm
U1: AS6C4008-55PCN; DIP-32_W15.24mm
U2: 74LS151; DIP-16_W7.62mm
U3: 74LS245; DIP-20_W7.62mm
U4: 74LS02; DIP-14_W7.62mm
U5: 74LS00; DIP-14_W7.62mm

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, D1.2 (A), J1.3 (VCC), J1.29 (VCC), J2.6, J2.58, R2.2, RN1.1 (common), U1.32 (VCC), U2.16 (VCC), U3.20 (VCC), U4.11, U4.12, U4.14 (VCC), U5.4, U5.14 (VCC); also elsewhere on the board
+12V: J1.9 (+12V), J2.18
-5V: J1.5 (-5V), J2.10
-12V: J1.7 (-12V), J2.14
A0: J1.62 (BA00), J2.61, U1.12 (A0)
A1: J1.61 (BA01), J2.59, U1.11 (A1)
A2: J1.60 (BA02), J2.57, U1.10 (A2)
A3: J1.59 (BA03), J2.55, U1.9 (A3)
A4: J1.58 (BA04), J2.53, U1.8 (A4)
A5: J1.57 (BA05), J2.51, U1.7 (A5)
A6: J1.56 (BA06), J2.49, U1.6 (A6)
A7: J1.55 (BA07), J2.47, U1.5 (A7)
A8: J1.54 (BA08), J2.45, U1.27 (A8)
A9: J1.53 (BA09), J2.43, U1.26 (A9)
A10: J1.52 (BA10), J2.41, U1.23 (A10)
A11: J1.51 (BA11), J2.39, U1.25 (A11)
A12: J1.50 (BA12), J2.37, U1.4 (A12)
A13: J1.49 (BA13), J2.35, U1.28 (A13)
A14: J1.48 (BA14), J2.33, U1.3 (A14)
A15: J1.47 (BA15), J2.31, U1.31 (A15)
A16: J1.46 (BA16), J2.29, U1.2 (A16), U5.10
A17: J1.45 (BA17), J2.27, U1.30 (A17), U2.11 (S0), U4.3
A18: J1.44 (BA18), J2.25, U1.1 (A18), U2.10 (S1), U4.2
A19: J1.43 (BA19), J2.23, U2.9 (S2), U5.9
AEN: J1.42 (AEN), J2.21
ALE: J1.28 (ALE), J2.56
BD0: U1.13 (DQ0), U3.9 (A7)
BD1: U1.14 (DQ1), U3.8 (A6)
BD2: U1.15 (DQ2), U3.7 (A5)
BD3: U1.17 (DQ3), U3.6 (A4)
BD4: U1.18 (DQ4), U3.5 (A3)
BD5: U1.19 (DQ5), U3.4 (A2)
BD6: U1.20 (DQ6), U3.3 (A1)
BD7: U1.21 (DQ7), U3.2 (A0)
CARDSEL: J1.8 (UNUSED), J2.16
CLK: J1.20 (CLK), J2.40
D0: J1.40 (DB0), J2.17, U3.11 (B7)
D1: J1.39 (DB1), J2.15, U3.12 (B6)
D2: J1.38 (DB2), J2.13, U3.13 (B5)
D3: J1.37 (DB3), J2.11, U3.14 (B4)
D4: J1.36 (DB4), J2.9, U3.15 (B3)
D5: J1.35 (DB5), J2.7, U3.16 (B2)
D6: J1.34 (DB6), J2.5, U3.17 (B1)
D7: J1.33 (DB7), J2.3, U3.18 (B0)
DECODED_CS: JP3.2, U2.6 (~Z), U4.9, U5.12, U5.13
DRQ1: J1.18 (DRQ1), J2.36
DRQ2: J1.6 (DRQ2), J2.12
DRQ3: J1.16 (DRQ3), J2.32
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J1.1 (GND), J1.10 (GND), J1.31 (GND), J2.2, J2.20, J2.62, JP1.1, JP2.1, SW1.1, SW1.2, SW1.3, SW1.4, SW1.5, SW1.6, SW1.7, SW1.8, U1.16 (VSS), U2.8 (GND), U3.10 (GND), U4.7 (GND), U5.7 (GND)
IOCHK: J1.32 (IO), J2.1
IORDY: J1.41 (IO_READY), J2.19
IRQ2: J1.4 (IRQ2), J2.8
IRQ3: J1.25 (IRQ3), J2.50
IRQ4: J1.24 (IRQ4), J2.48
IRQ5: J1.23 (IRQ5), J2.46
IRQ6: J1.22 (IRQ6), J2.44
IRQ7: J1.21 (IRQ7), J2.42
unnamed 57: D1.1 (K), R1.2; also elsewhere on the board
unnamed: JP1.2, R2.1, U2.7 (~E)
unnamed: JP2.2, U4.8
unnamed: JP2.3, U4.4
unnamed: R1.1, U5.3
unnamed: RN1.2 (R1), SW1.9, U2.12 (I7)
unnamed: RN1.3 (R2), SW1.10, U2.13 (I6)
unnamed: RN1.4 (R3), SW1.11, U2.14 (I5)
unnamed: RN1.5 (R4), SW1.12, U2.15 (I4)
unnamed: RN1.6 (R5), SW1.13, U2.1 (I3)
unnamed: RN1.7 (R6), SW1.14, U2.2 (I2)
unnamed: RN1.8 (R7), SW1.15, U2.3 (I1)
unnamed: RN1.9 (R8), SW1.16, U2.4 (I0)
unnamed: U4.1, U4.5
unnamed: U4.6, U5.8
unnamed: U4.10, U5.5
unnamed: U5.1, U5.2, U5.11
OSC: J1.30 (OSC), J2.60
RESET: J1.2 (RESET), J2.4
SRAM_CE: JP3.1, U1.22 (CE#), U3.19 (CE), U5.6
TC: J1.27 (TC), J2.54
~DACK0: J1.19 (~DACK0), J2.38
~DACK1: J1.17 (~DACK1), J2.34
~DACK2: J1.26 (~DACK2), J2.52
~DACK3: J1.15 (~DACK3), J2.30
~IOR: J1.14 (~IOR), J2.28
~IOW: J1.13 (~IOW), J2.26
~MEMR: J1.12 (~SMEMR), J2.24, U1.24 (OE#)
~MEMW: J1.11 (~SMEMW), J2.22, U1.29 (WE#), U3.1 (A->B)

Notes on the sheet:
128k/64k UMB Blocks
SPARES
SW1: BANK L1: 0-128k SW2: BANK L2: 128k-256k SW3: BANK L3: 256-384k SW4: BANK L4: 384-512k SW5: BANK H1: 512k-640k SW6: BANK H2: 640k-768k SW7: BANK H3: 768k-869k SW8: BANK H4: 869k-1024k
DIR LOW : B -> A DIR HIGH : A -> B

Board: 2 copper layers, 98.4 x 73.9 mm, 22 parts (0 on the bottom side), 86 nets.

Other parts of the board:
RAM Access: LED; LED_D3.0mm

Their connections:
+5V: RAM Access.2; also elsewhere on the board
unnamed 57: RAM Access.1; also elsewhere on the board

## Commit log

2024-08-12 Initial fix
